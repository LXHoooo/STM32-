# Keil uVision project 音频采集播放.uvprojx, settings and files
target 音频采集播放 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: 音频采集播放 +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,HAVE_CONFIG_H
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Speex_Lib\include\speex;..\Speex_Lib\libspeex;..\Speex_Lib\STM32\include\speex;..\Speex_Lib\STM32\libspeex\arm;..\Speex_Lib\STM32;..\Speex_Lib\include;..\Speex_Lib\STM32\include;..\Speex_Lib\STM32\libspeex\gcc;..\Speex_Lib\STM32\libspeex\iar;..\SEGGER\RTT;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\NVIC;..\HARDWARE\EDCode;..\HARDWARE\LCD;..\HARDWARE\NRF24L01;..\HARDWARE\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: README.TXT
  group SEGGER
    ../SEGGER/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group LIB_SPEEX
    ../Speex_Lib/libspeex/: bits.c buffer.c lpc.c lsp.c gain_table_lbr.c high_lsp_tables.c speex.c speex_callbacks.c speex_header.c window.c exc_10_32_table.c lsp_tables_nb.c
    ../Speex_Lib/STM32/libspeex/: cb_search.c filters.c ltp.c modes.c nb_celp.c quant_lsp.c vq.c
  group HARDWARE
    ../HARDWARE/ADC/: ADC.c
    ../HARDWARE/DAC/: DAC.c
    ../HARDWARE/KEY/: Key.c
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/NVIC/: NVIC.c
    ../HARDWARE/EDCode/: EDCode.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/SPI/: spi.c
